## uploader/main/Kconfig.projbuild
```kconfig
config SDU_UART_BAUD
    int "Uploader UART baud (must match tools/sd_upload.py --baud)"
    range 115200 4000000
    default 921600
```
